# Autodesk Inventor assembly: 21.0918 POWER-LOCK N
## iProperties
Created: 2006-12
Part Number: 21.0918 POWER-LOCK N
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
